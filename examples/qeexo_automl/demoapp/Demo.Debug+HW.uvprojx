# Keil uVision project Demo.Debug+HW.uvprojx, settings and files
target Debug+HW (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Demo.Debug+HW.axf
  c flags: Optim=2 v6Lang=5
  c define: MX_WIFI_SPI_DMA=0 RECORDER_ENABLED
  c misc: -fshort-enums
  c include: Board/B-U585I-IOT02A;Board/B-U585I-IOT02A/Driver;../../../sensor/include;.\qeexo
  asm define: MX_WIFI_SPI_DMA=0 RECORDER_ENABLED
  asm include: ../sds/include;Board/B-U585I-IOT02A;Board/B-U585I-IOT02A/Driver;../sensor/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: Board/B-U585I-IOT02A/RTE/Device/STM32U585AIIx/stm32u585xx_flash.sct
  link misc: --entry=Reset_Handler
  group Documentation
    ./: README.md
  group main
    ./: app_main.c demo.c
  group sds
    Y:/Documents/GitHub/SDS-Framework/sds/source/: sds.c sds_rec.c sdsio_socket.c
  group ml
    Y:/Documents/GitHub/SDS-Framework/demoapp/qeexo/: QxAutoMLSensorConfigs.c libQxClassifyEngine.a NativeFunction.cpp QxAutoMLWork.c
  group Board
    ./Board/B-U585I-IOT02A/: arduino.c retarget_stdio.c
    ./Board/B-U585I-IOT02A/Driver/: sensor_drv_hw.c ism330dhcx_fifo.c
    Y:/Documents/GitHub/SDS-Framework/sensor/source/: sensor_drv.c
  group Socket
    ./Socket/WiFi/: socket_startup.c
  group :STM32CubeMX:Common Sources
    ./Board/B-U585I-IOT02A/STM32CubeMX/Inc/: main.h stm32u5xx_it.h
    ./Board/B-U585I-IOT02A/STM32CubeMX/Src/: main.c stm32u5xx_it.c
    ./Board/B-U585I-IOT02A/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Board Support:Components:EMW3080 2.1.12, Board Support:Components:HTS221 5.3.2, Board Support:Components:IIS2MDC 1.1.2, Board Support:Components:ISM330DHCX 1.1.3, Board Support:Components:LPS22HH 1.2.2, Board Support:Drivers:BUS 1.1.0, Board Support:Drivers:Basic I/O 1.1.0, Board Support:Drivers:Environmental Sensors 1.1.0, Board Support:Drivers:Motion Sensors 1.1.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:VIO:Board 1.2.0, CMSIS Driver:WiFi:EMW3080 1.0.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:EXTI 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:ICACHE 1.1.0, Device:STM32Cube HAL:IRDA 1.1.0, Device:STM32Cube HAL:MDF 1.1.0, Device:STM32Cube HAL:OSPI 1.1.0, Device:STM32Cube HAL:PCD 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:RTC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:Smartcard 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:STM32Cube LL:Common 1.1.0, Device:STM32Cube LL:DLYB 1.1.0, Device:STM32Cube LL:GPIO 1.1.0, Device:STM32Cube LL:PWR 1.1.0, Device:STM32Cube LL:RCC 1.1.0, Device:STM32Cube LL:UCPD 1.1.0, Device:STM32Cube LL:UTILS 1.1.0, Device:Startup 1.1.0, IoT Utility:Socket:WiFi 1.0.0
